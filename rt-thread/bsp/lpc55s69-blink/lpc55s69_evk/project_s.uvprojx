# Keil uVision project project_s.uvprojx, settings and files
target rtthread-lpc55s6x (6140000::V6.14::ARMCLANG)
  device: LPC55S69JBD100:cm33_core0 NXP
  pack: NXP.LPC55S69_DFP.13.0.0
  cpu: IRAM(0x20000000,0x044000) IRAM2(0x04000000,0x8000) IROM(0x00000000,0x098000) XRAM(0x40100000,0x4000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: lpc55s6x_app_s
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=3
  c define: CPU_LPC55S69JBD100_cm33_core0, ARM_MATH_CM33,  NDEBUG,
  c misc: --target=arm-arm-none-eabi
  c include: .\applications_s;.\applications_s\trustzone;..\lpc55s69_evk;.\board;..\Libraries\drivers;..\Libraries\LPC55S69\CMSIS\Include;..\Libraries\LPC55S69\devices;..\Libraries\LPC55S69\devices\LPC55S69;..\Libraries\LPC55S69\devices\LPC55S69\drivers;..\Libraries\LPC55S69\middleware\sdmmc\inc;..\Libraries\LPC55S69\middleware\sdmmc\port
  asm define: NDEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x98000
  memory RVCT6: RAM 0x40100000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x44000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: .\board\linker_scripts\LPC55S69_cm33_core0_flash_mdk_s.scf
  link misc: --remove 
--import-cmse-lib-out="./build/lpc55s6x_app_s_CMSE_Lib.o"
  group Applications
    ./applications_s/: main.c app.h app_printf.c app_printf.h tz_context.c
    ./applications_s/trustzone/: tzm_config.c tzm_config.h veneer_table.c veneer_table.h
    ./board/: clock_config.c clock_config.h
  group CMSIS
    ../Libraries/LPC55S69/devices/LPC55S69/: system_LPC55S69_cm33_core0.c fsl_device_registers.h LPC55S69_cm33_core0.h system_LPC55S69_cm33_core0.h LPC55S69_cm33_core0_features.h
    ../Libraries/LPC55S69/devices/LPC55S69/arm/: startup_LPC55S69_cm33_core0.s
  group Libraries
    ../Libraries/LPC55S69/devices/LPC55S69/drivers/: fsl_anactrl.c fsl_casper.c fsl_clock.c fsl_cmp.c fsl_common.c fsl_crc.c fsl_ctimer.c fsl_dma.c fsl_flexcomm.c fsl_gint.c fsl_gpio.c fsl_hashcrypt.c fsl_i2c.c fsl_i2c_dma.c fsl_i2s.c fsl_i2s_dma.c fsl_iap.c fsl_inputmux.c fsl_lpadc.c fsl_mrt.c fsl_ostimer.c fsl_pint.c fsl_plu.c fsl_power.c fsl_prince.c fsl_puf.c fsl_reset.c fsl_rng.c fsl_rtc.c fsl_sctimer.c fsl_sdif.c fsl_spi.c fsl_spi_dma.c fsl_sysctl.c fsl_usart.c fsl_usart_dma.c fsl_utick.c fsl_wwdt.c
    ../Libraries/LPC55S69/devices/LPC55S69/arm/: keil_lib_power_cm33_core0.lib
