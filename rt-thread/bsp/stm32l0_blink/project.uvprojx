# Keil uVision project project.uvprojx, settings and files
target stm32l072 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L072KB STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: rtthread.axf
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: STM32L0X2, USE_FULL_LL_DRIVER
  c include: .;Drivers\CMSIS\Device\ST\STM32L0xx\Include;Drivers\STM32L0xx_HAL_Driver\Inc;Inc;drivers;drivers..\Drivers\CMSIS\Device\ST\STM32L0xx\Include;DriversSTM32L0xx_HAL_Driver\Inc;DriversCMSIS\Device\ST\STM32L0xx\Include;Drivers\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Applications
    ./: main.c
  group STM32_HAL
    Drivers/CMSIS/Device/ST/STM32L0xx/Source/Templates/: system_stm32l0xx.c
    Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_ll_adc.c stm32l0xx_ll_comp.c stm32l0xx_ll_crc.c stm32l0xx_ll_crs.c stm32l0xx_ll_dac.c stm32l0xx_ll_dma.c stm32l0xx_ll_exti.c stm32l0xx_ll_gpio.c stm32l0xx_ll_i2c.c stm32l0xx_ll_lptim.c stm32l0xx_ll_lpuart.c stm32l0xx_ll_pwr.c stm32l0xx_ll_rcc.c stm32l0xx_ll_rng.c stm32l0xx_ll_rtc.c stm32l0xx_ll_spi.c stm32l0xx_ll_tim.c stm32l0xx_ll_usart.c stm32l0xx_ll_utils.c
    Drivers/CMSIS/Device/ST/STM32L0xx/Source/Templates/arm/: startup_stm32l072xx.s
software components: CMSIS:CORE 5.1.2, RTOS:kernel 3.1.3
