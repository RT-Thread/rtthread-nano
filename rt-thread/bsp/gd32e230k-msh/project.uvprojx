# Keil uVision project project.uvprojx, settings and files
target rt-thread_gd32e230 (6150000::V6.15::.\ARMCCv615)
  device: GD32E230K8 GigaDevice
  pack: GigaDevice.GD32E23x_DFP.1.0.0
  cpu: IRAM(0x20000000,0x0002000) IROM(0x08000000,0x0010000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: rtthread-gd32e230
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: GD32E230
  c include: .;..\..\include;applications;Libraries\CMSIS\GD\GD32E230\Include;Libraries\CMSIS;Libraries\GD32E230_standard_peripheral\Include;..\..\libcpu\arm\common;..\..\libcpu\arm\cortex-m23;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\drivers\spi;..\..\components\drivers\include;..\..\components\drivers\spi\sfud\inc;..\..\components\drivers\include;..\..\components\libc\compilers\common;.\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Applications
    applications/: main.c
  group GD32_Lib
    Libraries/GD32E230_standard_peripheral/Source/: gd32e230_adc.c gd32e230_cmp.c gd32e230_crc.c gd32e230_dbg.c gd32e230_dma.c gd32e230_exti.c gd32e230_fmc.c gd32e230_fwdgt.c gd32e230_gpio.c gd32e230_i2c.c gd32e230_misc.c gd32e230_pmu.c gd32e230_rcu.c gd32e230_rtc.c gd32e230_spi.c gd32e230_syscfg.c gd32e230_timer.c gd32e230_usart.c gd32e230_wwdgt.c
    Libraries/CMSIS/GD/GD32E230/Source/: system_gd32e230.c
    Libraries/CMSIS/GD/GD32E230/Source/ARM/: startup_gd32e230.s
software components: CMSIS:CORE 5.4.0, RTOS:kernel 3.1.5, RTOS:shell 3.1.5
